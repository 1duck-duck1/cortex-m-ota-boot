# Keil uVision project Keil_App.uvprojx, settings and files
target App_Slot_A (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: App_Slot_A +hex
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bin --output="Keil_App\App_Slot_A\App_Slot_A.bin" "!L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,APP_SLOT_A
  c include: ../Core/Inc;../App/Config;../App/BootClient/Inc;../App/Platform/Inc;../App/Services/Inc;../../Common/ota;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Keil_App_Slot_A.sct
  group Platform/Startup
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group App/BootClient
    ../App/BootClient/Src/: app_boot_client.c
  group App/Platform
    ../App/Platform/Src/: app_flash.c app_transport.c
  group App/Services
    ../App/Services/Src/: app_cli.c app_nvs.c app_ota_service.c app_slot_writer.c
  group Common/ota
    ../../Common/ota/: ota_cli.c ota_crc32.c ota_image.c ota_request.c ota_ymodem.c
target App_Slot_B (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: App_Slot_B +hex
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bin --output="Keil_App\App_Slot_B\App_Slot_B.bin" "!L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -DAPP_SLOT_B
  c include: as above
  memory RVCT4: ROM 0x8080000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: ./Keil_App_Slot_B.sct
software components: CMSIS:CORE 6.1.0
