# Keil uVision project Keil_OTA_Boot.uvprojx, settings and files
target Keil_OTA_Boot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Keil_OTA_Boot +hex
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bin --output="Keil_OTA_Boot\Keil_OTA_Boot.bin" "!L"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Boot/Config;../Boot/Core/Inc;../Boot/Storage/Inc;../Boot/Mailbox/Inc;../Boot/Protocol/Inc;../Boot/Crypto/Inc;../Boot/Crypto/monocypher;../../Common/ota
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\Keil_OTA_Boot.sct
  group Platform/Startup
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Common/ota
    ../../Common/ota/: ota_cli.c ota_crc32.c ota_image.c ota_request.c ota_ymodem.c
  group Boot/Storage
    ../Boot/Storage/Src/: boot_adopt.c boot_flash.c boot_image.c boot_metadata.c boot_nvs.c boot_slot_writer.c
  group Boot/Mailbox
    ../Boot/Mailbox/Src/: boot_mailbox.c
  group Boot/Core
    ../Boot/Core/Src/: boot_jump.c boot_main.c
  group Boot/Protocol
    ../Boot/Protocol/Src/: boot_cli.c boot_transport.c boot_update.c
  group Boot/Crypto
    ../Boot/Crypto/Src/: boot_pubkey.c boot_verify.c
  group Boot/Crypto/Monocypher
    ../Boot/Crypto/monocypher/: monocypher.c monocypher-ed25519.c
software components: CMSIS:CORE 4.3.0
